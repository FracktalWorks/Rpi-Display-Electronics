# Repository FracktalWorks/Rpi-Display-Electronics

## EAGLE design Display Board/V1.brd

Parts:
JP1: PINHD-2X13; 2X13
K1: FFC/FPC/34PIN/1MMPITCH/TOPLOCK
SG1: F/CM12P

Connections:
3V3: JP1.9, JP1.25, K1.1, K1.17
5V: JP1.24, JP1.26, K1.2, K1.4
BUZZER: K1.27, SG1.+ (1)
GND: JP1.1, JP1.8, JP1.14, JP1.17, JP1.22, K1.6, K1.9, K1.14, K1.20, K1.25, SG1.- (2)
unnamed: JP1.23, K1.3
unnamed: JP1.21, K1.5
unnamed: JP1.19, K1.7
unnamed: JP1.20, K1.8
unnamed: JP1.18, K1.10
unnamed: JP1.15, K1.11
unnamed: JP1.16, K1.12
unnamed: JP1.13, K1.13
unnamed: JP1.11, K1.15
unnamed: JP1.12, K1.16
unnamed: JP1.10, K1.18
unnamed: JP1.7, K1.19
unnamed: JP1.5, K1.21
unnamed: JP1.6, K1.22
unnamed: JP1.3, K1.23
unnamed: JP1.4, K1.24
unnamed: JP1.2, K1.26

Board: 2 copper layers, 52.5 x 30.0 mm, 3 parts (1 on the bottom side), 21 nets.

File Display Board/BOM and Centroids/RPi Display Board V1 BOM.csv:

Qty,Designator,Footprints,Comment,LCSC Part #,Description,Value
1,JP1,2X13,PINHD-2X13,,PIN HEADER,
1,SG1,F/CM12P,F/CM12P,,BUZZER Source: Buerklin,F/CM12P
1,K1,FFC/FPC/34PIN/1MMPITCH/TOPLOCK,FFC/FPC/34PIN/1MMPITCH/TOPLOCK,,,FFC/FPC/34PIN/1MMPITCH/TOPLOCK
1,U$1,FRACKTALLOGO,FRACKTALLOGO,,,FRACKTALLOGO

## Commit log

2020-01-16 added display board gerbers
2023-02-02 Updated BOM and Centroid files
